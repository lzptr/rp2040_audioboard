# Repository lzptr/rp2040_audioboard

File README.md:

# rp2040_audioboard
Mixed signal audio board using the rp2040:

For an interactive KiCad experience see:
[RP2040 Audioboard](https://kicanvas.org/?github=https://github.com/lzptr/rp2040_audioboard/tree/main/hardware).

This project is a variation of the board from phils lab mixed signal course (https://www.phils-lab.net/courses).
It's purpose is to serve as a general input/output signal analyzer/generator for audio projects.

## KiCad design hardware/rp2040_audioboard.kicad_pcb

Board: 4 copper layers, 65.0 x 75.0 mm, 124 parts (0 on the bottom side), 72 nets.

Parts:
C101, C102, C403: 1u; C_0603_1608Metric
C103, C104, C106, C107, C108: 22u; C_0805_2012Metric
C105: DNP; C_0402_1005Metric
C109, C203, C204, C207, C208, C209, C210, C211, C212, C213, C214, C215, C217, C304, C307, C308, C309, C310, C315, C402, C407: 100n; C_0402_1005Metric
C201, C202: 30pF; C_0402_1005Metric
C205, C206, C216: 1u; C_0402_1005Metric
C301, C302, C305, C306, C312, C401: 10u; C_0603_1608Metric
C303, C314, C316, C406: 150p; C_0402_1005Metric
C311, C313, C404, C405: 1n; C_0402_1005Metric
D101: 3.3V; LED_0603_1608Metric
D102: 3.3VA; LED_0603_1608Metric
D201, D202, D203, D204, D301, D401: PESD3V3L1BA; D_SOD-323
D205: Act; LED_0603_1608Metric
H1, H2, H3, H4: GND; MountingHole_3.2mm_M3_Pad
J201: 2x5 1.27mm; PinHeader_2x05_P1.27mm_Vertical_SMD
J202: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J301, J401: 031-5640-1010; AMPHENOL-BNC-031-5640-1010
L101: 10n; L_0402_1005Metric
L102: 68u; MWSA0603S
L201: CMF3216F-900-2P-T; CMC-1206
R101: 10R; R_0805_2012Metric
R102: 464k; R_0402_1005Metric
R103: 100k; R_0402_1005Metric
R104, R105, R106, R107, R203, R209, R210, R211, R302, R309, R310: 1k; R_0402_1005Metric
R201, R202: 27; R_0402_1005Metric
R204, R205, R206, R406: 49R9; R_0402_1005Metric
R207, R208: 5k1; R_0402_1005Metric
R212: DNP 10k; R_0402_1005Metric
R213, R402: 10k; R_0402_1005Metric
R301: 49R9; R_0805_2012Metric
R303, R304: 2M2; R_0402_1005Metric
R305, R403: 6k8; R_0402_1005Metric
R306, R401: 0R; R_0402_1005Metric
R307, R404: 22k; R_0402_1005Metric
R308, R405: 12k; R_0402_1005Metric
SW201: RESET; SW_TL3365AF180QG
SW202: BOOTSEL; SW_TL3365AF180QG
TP102: 5V; TestPoint_Pad_D1.0mm
TP103: 3.3V; TestPoint_Pad_D1.0mm
TP104: 3.3VA; TestPoint_Pad_D1.0mm
TP105: VCOM; TestPoint_Pad_D1.0mm
U101: TLV62569DBV; SOT-23-5
U102: HT7533-1; SOT-89-3
U103, U302, U304, U402: TLV9001IDBVR; SOT-23-5
U201: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U202: USBLC6-2SC6; SOT-23-6
U203: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U301: REF3033AIDBZT; SOT-23
U303: ADC141S626CIMM_NOPB; VSSOP-10
U401: DAC7562SDGSR; VSSOP-10
Y201: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C203.1, C204.1, C205.1, U201.23 (DVDD), U201.45 (VREG_VOUT), U201.50 (DVDD)
+3.3V: C104.1, C105.1, C206.1, C207.1, C208.1, C209.1, C210.1, C211.1, C212.1, C213.1, C216.1, C217.1, C310.1, C312.1, C401.1, C402.1, D101.2 (A), D201.1 (A1), J201.1, L102.2, R102.1, R212.2, R213.1, TP103.1, U201.1 (IOVDD), U201.10 (IOVDD), U201.22 (IOVDD), U201.33 (IOVDD), U201.42 (IOVDD), U201.43 (ADC_AVDD), U201.44 (VREG_IN), U201.48 (USB_VDD), U201.49 (IOVDD), U203.8 (VCC), U303.9 (VIO), U401.9 (AVDD)
+3.3VA: C107.1, C109.2, C305.1, C307.1, C309.1, C315.1, C407.1, D102.2 (A), R106.1, TP104.1, U102.3 (VOUT), U103.5 (V+), U302.5 (V+), U303.10 (VA), U304.5 (V+), U402.5 (V+)
+5V: C102.1, C103.1, C301.1, L101.2, R101.1, R301.1, TP102.1, U101.1 (EN), U101.4 (VIN)
/[1] Power/+5V_filt: C106.1, R101.2, U102.2 (VIN)
/[1] Power/BUCK_FB: C105.2, R102.2, R103.1, U101.5 (FB)
/[1] Power/BUCK_SW: L102.1, U101.3 (SW)
/[1] Power/VREF: C108.1, R106.2, R107.1, U103.3 (+)
/[2] MCU/ACT_LED: D205.2 (A), U201.14 (GPIO11)
/[2] MCU/ADC_SPI1_CLK: R306.2, U201.29 (GPIO18)
/[2] MCU/ADC_SPI1_MISO: U201.31 (GPIO20), U303.7 (DOUT)
/[2] MCU/ADC_SPI1_NCS: U201.32 (GPIO21), U303.6 (NCS)
/[2] MCU/CONN_NRST: D204.1 (A1), J201.10, R206.2
/[2] MCU/CONN_SWCLK: D203.1 (A1), J201.4, R205.2
/[2] MCU/CONN_SWDIO: D202.1 (A1), J201.2, R204.2
/[2] MCU/CR_XOUT: C202.1, R203.1, Y201.3
/[2] MCU/DAC_NCLR: U201.39 (GPIO27_ADC1), U401.5 (NCLR)
/[2] MCU/DAC_NLDAC: U201.38 (GPIO26_ADC0), U401.4 (NLDAC)
/[2] MCU/DAC_SPI0_CLK: R401.1, U201.34 (GPIO22)
/[2] MCU/DAC_SPI0_MOSI: U201.35 (GPIO23), U401.8 (DIN)
/[2] MCU/DAC_SPI0_NCS: U201.37 (GPIO25), U401.6 (NSYNC)
/[2] MCU/QSPI_CS: R212.1, SW202.1, SW202.2, U201.56 (QSPI_SS), U203.1 (~CS)
/[2] MCU/QSPI_SCLK: U201.52 (QSPI_SCLK), U203.6 (CLK)
/[2] MCU/QSPI_SD0: U201.53 (QSPI_SD0), U203.5 (DI(IO0))
/[2] MCU/QSPI_SD1: U201.55 (QSPI_SD1), U203.2 (DO(IO1))
/[2] MCU/QSPI_SD2: U201.54 (QSPI_SD2), U203.3 (IO2)
/[2] MCU/QSPI_SD3: U201.51 (QSPI_SD3), U203.7 (IO3)
/[2] MCU/RUN: C214.1, R206.1, R213.2, SW201.1, SW201.2, U201.26 (RUN)
/[2] MCU/SWCLK: R205.1, U201.24 (SWCLK)
/[2] MCU/SWDIO: R204.1, U201.25 (SWD)
/[2] MCU/USB_CMC_D+: L201.2, U202.4 (I/O2)
/[2] MCU/USB_CMC_D-: L201.1, U202.6 (I/O1)
/[2] MCU/USB_CONN_CC1: J202.A5 (CC1), R207.1
/[2] MCU/USB_CONN_CC2: J202.B5 (CC2), R208.1
/[2] MCU/USB_CONN_D+: J202.A6 (D+), J202.B6 (D+), U202.3 (I/O2)
/[2] MCU/USB_CONN_D-: J202.A7 (D-), J202.B7 (D-), U202.1 (I/O1)
/[2] MCU/USB_D+: L201.3, R201.1
/[2] MCU/USB_D-: L201.4, R202.1
/[2] MCU/USB_DT+: R201.2, U201.47 (USB_DP)
/[2] MCU/USB_DT-: R202.2, U201.46 (USB_DM)
/[2] MCU/XIN: C201.1, U201.20 (XIN), Y201.1
/[2] MCU/XOUT: R203.2, U201.21 (XOUT)
/[3] ADC/ADC_IN+: C316.1, R309.1, U303.2 (+IN)
/[3] ADC/ADC_IN-: C316.2, R310.1, U303.3 (-IN)
/[3] ADC/ADC_SCLK: R306.1, U303.8 (SCLK)
/[3] ADC/ADC_VREF: C306.1, C308.1, U301.2 (OUT), U303.1 (VREF)
/[3] ADC/ADC_VREF_VIN: C302.1, R301.2, U301.1 (IN)
/[3] ADC/IN: D301.1 (A1), J301.1 (In), R302.2
/[3] ADC/IN_AA_BUF_IN: C314.1, R308.1, U304.3 (+)
/[3] ADC/IN_AA_BUF_OUT: C313.2, R309.2, U304.1, U304.4 (-)
/[3] ADC/IN_BUF: C304.1, R304.1, U302.3 (+)
/[3] ADC/IN_BUF_OUT: R305.2, U302.1, U302.4 (-)
/[3] ADC/IN_RF: C303.1, C304.2, R302.1, R303.2
/[4] DAC/DAC_OUT_A: R403.2, U401.1 (VOUT_A)
/[4] DAC/DAC_OUT_B: R402.1, U401.2 (VOUT_B)
/[4] DAC/DAC_SCLK: R401.2, U401.7 (SCLK)
/[4] DAC/DAC_VREF: C403.1, U401.10 (VREFIN/VREFOUT)
/[4] DAC/OUT: D401.1 (A1), J401.1 (In), R406.1
/[4] DAC/OUT_AA_BUF_IN: C406.1, R405.1, U402.3 (+)
/[4] DAC/OUT_AA_BUF_OUT: C405.2, R406.2, U402.1, U402.4 (-)
GND: C101.2, C102.2, C103.2, C104.2, C106.2, C107.2, C108.2, C109.1, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C301.2, C302.2, C303.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C314.2, C315.2, C401.2, C402.2, C403.2, C404.2, C406.2, C407.2, D201.2 (A2), D202.2 (A2), D203.2 (A2), D204.2 (A2), D301.2 (A2), D401.2 (A2), H1.1, H2.1, H3.1, H4.1, J201.3, J201.5, J201.9, J202.A1 (GND), J202.A12 (GND), J202.B1 (GND), J202.B12 (GND), J301.2 (Ext), J401.2 (Ext), R103.2, R104.2, R105.2, R107.2, R207.2, R208.2, R209.1, R210.1, R211.2, R303.1, R402.2, U101.2 (GND), U102.1 (GND), U103.2 (V-), U201.19 (TESTEN), U201.57 (GND), U202.2 (GND)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
unnamed: C311.1, R305.1, R307.2
unnamed: C313.1, R307.1, R308.2
unnamed: C404.1, R403.1, R404.2
unnamed: C405.1, R404.1, R405.2
unnamed: D101.1 (K), R104.1
unnamed: D102.1 (K), R105.1
unnamed: D205.1 (K), R211.1
unnamed: R209.2, SW201.3, SW201.4
unnamed: R210.2, SW202.3, SW202.4
VBUS: C101.1, C215.1, J202.A4 (VBUS), J202.A9 (VBUS), J202.B4 (VBUS), J202.B9 (VBUS), L101.1, U202.5 (VBUS)
VCOM: R304.2, R310.2, TP105.1, U103.1, U103.4 (-)

File hardware/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C101, C102, C403",0603,3,1u,C15849
"C103, C104, C106, C107, C108",0805,5,22u,C45783
C105,0402,1,DNP,
"C109, C203, C204, C207, C208, C209, C210, C211, C212, C213, C214, C215, C217, C304, C307, C308, C309, C310, C315, C402, C407",0402,21,100n,C1525
"C201, C202",0402,2,30pF,C1570
"C205, C206, C216",0402,3,1u,C52923
"C301, C302, C305, C306, C312, C401",0603,6,10u,C96446
"C303, C314, C316, C406",0402,4,150p,C1527
"C311, C313, C404, C405",0402,4,1n,C1523
D101,0603,1,3.3V,C72043
D102,0603,1,3.3VA,C72043
"D201, D202, D203, D204, D301, D401",D_SOD-323,6,PESD3V3L1BA,
D205,0603,1,Act,C72043
"H1, H2, H3, H4",MountingHole_3.2mm_M3_Pad,4,GND,
J201,PinHeader_2x05_P1.27mm_Vertical_SMD,1,2x5 1.27mm,C598540
J202,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB_C_Receptacle_USB2.0,C165948
"J301, J401",AMPHENOL-BNC-031-5640-1010,2,031-5640-1010,
L101,0402,1,10n,C361500
L102,MWSA0603S,1,68u,C408441
L201,CMC-1206,1,CMF3216F-900-2P-T,C963740
R101,0805,1,10R,C17415
R102,0402,1,464k,C321525
R103,0402,1,100k,C25741
"R104, R105, R106, R107, R203, R209, R210, R211, R302, R309, R310",0402,11,1k,C11702
"R201, R202",0402,2,27,C321419
"R204, R205, R206, R406",0402,4,49R9,C25120
"R207, R208",0402,2,5k1,C25905
"R213, R402",0402,2,10k,C25744
R301,0805,1,49R9,C17720
"R303, R304",0402,2,2M2,C174169
"R305, R403",0402,2,6k8,C25917
"R306, R401",0402,2,0R,C17168
"R307, R404",0402,2,22k,C25768
"R308, R405",0402,2,12k,C25752
SW201,SW_TL3365AF180QG,1,RESET,C2886926
SW202,SW_TL3365AF180QG,1,BOOTSEL,C2886926
TP102,TestPoint_Pad_D1.0mm,1,5V,
TP103,TestPoint_Pad_D1.0mm,1,3.3V,
TP104,TestPoint_Pad_D1.0mm,1,3.3VA,
TP105,TestPoint_Pad_D1.0mm,1,VCOM,
U101,SOT-23-5,1,TLV62569DBV,C141836
U102,SOT-89-3,1,HT7533-1,C14289
"U103, U302, U304, U402",SOT-23-5,4,TLV9001IDBVR,C398363
U201,QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm,1,RP2040,C2040
U202,SOT-23-6,1,USBLC6-2SC6,C5261088
U203,SOIC-8_5.23x5.23mm_P1.27mm,1,W25Q128JVS,C97521
U301,SOT-23,1,REF3033AIDBZT,C2872391
U303,VSSOP-10,1,ADC141S626CIMM_NOPB,C206494
U401,VSSOP-10,1,DAC7562SDGSR,C1554786
Y201,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,Crystal_GND24,C9002

## Commit log

2023-05-01 Initial commit rp2040 audioboard
2023-05-06 Finished mcu schematic with the rp2040
2023-05-12 Finished rp2040 schematic
2023-05-13 Finished layout changes
2023-05-14 Finished routing
2023-05-19 Finished bom
2023-06-21 Cleanup, minor bom changes and finished production files
2023-06-21 Updated documentation
2023-07-08 Fixed missing pull up for run pin
2023-07-08 Changes to buttons
2023-07-08 Added blinky firmware project for board
2023-07-09 Added bsp file to add a startup delay due to slow oscillator stabilization time.
2024-02-24 Updated to kicad 8
2024-02-24 Updated footprints and fixed drc warnings
2024-07-29 Switched to gdb-multiarch and fixed custom pico board type in task.json
