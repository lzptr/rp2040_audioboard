File: hardware/rp2040_audioboard.kicad_pcb (KiCad board)
At the start: 4 copper layers, 65 x 75 mm, 124 parts, among them J201 2x5 1.27mm, J202 USB_C_Receptacle_USB2.0, J301 031-5640-1010, J401 031-5640-1010, SW201 RESET, SW202 BOOTSEL, U101 TLV62569DBV, U102 HT7533-1, U103 TLV9001IDBVR, U201 RP2040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

Commit message: Updated footprints and fixed drc warnings
